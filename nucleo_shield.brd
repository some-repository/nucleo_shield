# Repository some-repository/nucleo_shield

## EAGLE design nucleo_shield.brd

Parts:
C2, C3, C4, C5, C6, C7, C8, C9: C-EUC0603; C0603
CFG: SWS001; SMS-001
D1, D2: D-FILL-SOD123; SOD123
KEY1, KEY2, KEY3, KEY4, KEY5, KEY6, KEY7, KEY8: SWS001; SMS-001
LEARN: SWS001; SMS-001
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9: LEDCHIPLED_0603; CHIPLED_0603
MIDI_IN: MAB5WH
MIDI_OUT: MAB5WH
NEXT: SWS001; SMS-001
OK1: 6N138; DIL08
PREV: SWS001; SMS-001
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29: R-EU_R0603; R0603
T2, T3, T4, T5, T6, T7, T8, T9: MMBT3904LT1-NPN-SOT23-BEC; SOT23-BEC
U1: NUCLEO-F446RE; MODULE_NUCLEO-F446RE
X1, X2, X3, X4, X5, X6, X7, X8: 22-23-2021

Connections:
+3V3: D1.2 (A), R10.1, R29.2, U1.CN6_4 (CN6_+3V3), U1.CN7_16 (CN7_+3V3)
+5V: OK1.8 (VCC), U1.CN6_5 (CN6_+5V), U1.CN7_18 (CN7_+5V)
AGND: U1.CN10_32 (AGND)
AREF: U1.CN5_8 (AREF)
AVDD: U1.CN10_7 (AVDD)
CN6_VIN: U1.CN6_8 (CN6_VIN)
CN7_VIN: U1.CN7_24 (CN7_VIN)
E5V: U1.CN7_6 (E5V)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, CFG.2, LEARN.2, MIDI_OUT.1, NEXT.2, OK1.5 (GND), PREV.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.2, R7.1, R8.1, R9.1, T2.E, T3.E, T4.E, T5.E, T6.E, T7.E, T8.E, T9.E, U1.CN5_7 (CN5_GND), U1.CN6_6 (CN6_GND), U1.CN6_7 (CN6_GND), U1.CN7_8 (CN7_GND), U1.CN7_19 (CN7_GND), U1.CN7_20 (CN7_GND), U1.CN7_22 (CN7_GND), U1.CN10_9 (CN10_GND), U1.CN10_20 (CN10_GND)
unnamed: LED1.A, U1.CN7_34 (PB0)
unnamed: LED2.A, U1.CN10_24 (PB1)
unnamed: LED3.A, U1.CN10_22 (PB2)
unnamed: LED4.A, U1.CN10_3 (PB8)
unnamed: LED5.A, U1.CN10_5 (PB9)
unnamed: LED6.A, U1.CN10_29 (PB5)
unnamed: LED7.A, U1.CN10_17 (PB6)
unnamed: LED8.A, U1.CN7_21 (PB7)
unnamed: LED8.C, R7.2
unnamed: LED7.C, R8.2
unnamed: LED6.C, R9.2
unnamed: LED5.C, R1.2
unnamed: LED4.C, R2.2
unnamed: LED3.C, R3.2
unnamed: LED2.C, R4.2
unnamed: LED1.C, R5.2
unnamed: D1.1 (C), KEY1.1, KEY2.1, KEY3.1, KEY4.1, KEY5.1, KEY6.1, KEY7.1, KEY8.1
unnamed: LED9.A, U1.CN10_11 (PA5)
unnamed: LED9.C, R6.1
unnamed: PREV.1, U1.CN7_3 (PC12)
unnamed: CFG.1, U1.CN7_23 (PC13)
unnamed: R11.1, R12.1, T2.B
unnamed: R11.2, X1.1, X1.2
unnamed: KEY1.2, R12.2
unnamed: LEARN.1, U1.CN10_2 (PC8)
unnamed: R13.1, R14.1, T3.B
unnamed: R13.2, X2.1, X2.2
unnamed: KEY2.2, R14.2
unnamed: NEXT.1, U1.CN10_1 (PC9)
unnamed: R15.1, R16.1, T4.B
unnamed: R15.2, X3.1, X3.2
unnamed: KEY3.2, R16.2
unnamed: D2.1 (C), OK1.2 (A), R27.2
unnamed: R17.1, R18.1, T5.B
unnamed: R17.2, X4.1, X4.2
unnamed: KEY4.2, R18.2
unnamed: MIDI_OUT.2, R29.1
unnamed: R19.1, R20.1, T6.B
unnamed: R19.2, X5.1, X5.2
unnamed: KEY5.2, R20.2
unnamed: OK1.6 (VO), R10.2, U1.CN7_2 (PC11)
unnamed: R21.1, R22.1, T7.B
unnamed: R21.2, X6.1, X6.2
unnamed: KEY6.2, R22.2
unnamed: R28.2, U1.CN10_21 (PA9)
unnamed: R23.1, R24.1, T8.B
unnamed: R23.2, X7.1, X7.2
unnamed: KEY7.2, R24.2
unnamed: D2.2 (A), MIDI_IN.3, OK1.3 (C)
unnamed: R25.1, R26.1, T9.B
unnamed: R25.2, X8.1, X8.2
unnamed: KEY8.2, R26.2
unnamed: MIDI_IN.2, R27.1
unnamed: MIDI_OUT.3, R28.1
PC0: C2.1, T2.C, U1.CN7_38 (PC0/PB8)
PC1: C3.1, T3.C, U1.CN7_36 (PC1/PB9)
PC2: C4.1, T4.C, U1.CN7_35 (PC2)
PC3: C5.1, T5.C, U1.CN7_37 (PC3)
PC4: C6.1, T6.C, U1.CN10_34 (PC4)
PC5: C7.1, T7.C, U1.CN10_6 (PC5)
PC6: C8.1, T8.C, U1.CN10_4 (PC6)
PC7: C9.1, T9.C, U1.CN10_19 (PC7)
PE: MIDI_IN.PE, MIDI_IN.PE@ (PE), MIDI_OUT.PE, MIDI_OUT.PE@ (PE)
U5V: U1.CN10_8 (U5V)
VBAT: U1.CN7_33 (VBAT)
VDD: U1.CN7_5 (VDD)

Board: 2 copper layers, 99.5 x 71.0 mm, 80 parts (15 on the bottom side), 66 nets.

## Commit log

2021-06-19 First commit, PCB without polygon
2021-06-19 Added polygons
2021-06-19 Some fixes
2021-06-19 Deleted orphans
2021-06-19 Fixed polygons
2021-06-19 Some fixes and CAM files for jlcpcb
2021-06-19 Fixed mask on vias
2021-06-23 Reduced size of PCB
2021-06-23 Added pictures
2021-06-23 Fixed polarity
